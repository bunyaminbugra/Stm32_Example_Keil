# Keil uVision project lcd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F070RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0xx,HSE_VALUE=8000000
  c include: ..\Yeni klasör;.\RTE\_Target_1
  asm include: ..\Yeni klasör
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c lcd.c lcd.h
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL 1.7.0, Device:Startup 2.3.3
