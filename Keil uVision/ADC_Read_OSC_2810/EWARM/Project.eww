<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADC_Read_OSC_2810.ewp</path>
  </project>
  <batchBuild />
</workspace>
